Commit message: A4

File: urdf/arm.urdf (robot description, URDF)
Before this commit: robot arm, 4 links, 3 joints
Joints:
- joint joint_1: origin xyz=0.0 0.340 -0.07 -> xyz=0.0 0.340 0.07
- joint jonit_fixed: origin xyz=0.0 0.0 -0.120 rpy=0.0 0.0 0.0 -> xyz=0.0 0.0 0.120 rpy=0.0 0.0 0.0
